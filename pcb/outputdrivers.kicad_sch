File: pcb/outputdrivers.kicad_sch (KiCad schematic)
At the start: 30 parts, among them IC1 DRV8874QPWPRQ1, J7 CP/PE, J7 RF, Q1 BC846, Q2 NCV8402xST, Q3 NCV8402xST, Q4 DTA143Z, Q7 DTC114E, Q8 DTC114E, Q9 DTC114E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

Commit message: all 100nF now 0805. Todo list cleaned up.
Parts:
- added C61: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol Device:C_Small
Connections:
- net 12V_P: now also C61.2
- net GND: now also C61.1
Changed lines of the file:
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@@
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 259.08 135.89) (xy 267.97 135.89))
     (stroke (width 0) (type default))
   )
@@
     )
   )
+  (symbol (lib_name "C_Small_13") (lib_id "Device:C_Small") (at 270.51 135.89 270) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "C61" (at 270.51 132.08 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Value" "100nF" (at 273.05 132.08 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder" (at 270.51 135.89 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 270.51 135.89 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LCSC" "C14663" (at 270.51 135.89 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (instances
+      (project "qca7000"
+        (path "/e63e39d7-6ac0-4ffd-8aa3-1841a4541b55"
+          (reference "C61") (unit 1)
+        )
+        (path "/e63e39d7-6ac0-4ffd-8aa3-1841a4541b55/5666e7cf-6b6c-4583-8335-aa3be69ccd45"
+          (reference "C68") (unit 1)
+        )
+        (path "/e63e39d7-6ac0-4ffd-8aa3-1841a4541b55/93c6207c-4203-4bc7-a590-e5e89c0d3d27"
+          (reference "C79") (unit 1)
+        )
+        (path "/e63e39d7-6ac0-4ffd-8aa3-1841a4541b55/539ec63d-ac7e-42ea-858e-ff2bf33430ea"
+          (reference "C25") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "power:GND") (at 97.79 38.1 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
@@
     )
   )
+  (symbol (lib_id "power:GND") (at 273.05 135.89 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "#PWR048" (at 273.05 142.24 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 275.59 139.7 0)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Footprint" "" (at 273.05 135.89 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 273.05 135.89 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "qca7000"
+        (path "/e63e39d7-6ac0-4ffd-8aa3-1841a4541b55"
+          (reference "#PWR048") (unit 1)
+        )
+        (path "/e63e39d7-6ac0-4ffd-8aa3-1841a4541b55/5666e7cf-6b6c-4583-8335-aa3be69ccd45"
+          (reference "#PWR069") (unit 1)
+        )
+        (path "/e63e39d7-6ac0-4ffd-8aa3-1841a4541b55/539ec63d-ac7e-42ea-858e-ff2bf33430ea"
+          (reference "#PWR098") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "DRV8874QPWPRQ1:DRV8874QPWPRQ1") (at 199.39 127 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
   (symbol (lib_id "Device:C_Small") (at 256.54 135.89 90) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "C17" (at 262.89 134.62 90)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Value" "100nF" (at 262.89 137.16 90)
-      (effects (font (size 1.27 1.27)))
-    )
+    (property "Reference" "C17" (at 256.54 133.35 90)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Value" "100nF" (at 256.54 137.16 90)
+      (effects (font (size 1.27 1.27)))
+    )

Commit message: added CP sensing. Added 5V on the connector. Created gerber and pdf
Parts:
- added R3: 100k, Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder, symbol Device:R_Small
Connections:
- net at D10.1 (K), R3.2, R3.2: now also R3.2
- new net CP_SENSE: R3.1
Other:
- moved on the sheet: J7
Changed lines of the file:
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@@
   (junction (at 160.02 128.27) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 67.31 39.37) (diameter 0) (color 0 0 0 0)
   )
   (junction (at 48.26 124.46) (diameter 0) (color 0 0 0 0)
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 78.74 39.37) (xy 82.55 39.37))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 189.23 144.78) (xy 199.39 144.78))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 93.98 35.56) (xy 97.79 35.56))
+  (wire (pts (xy 102.87 33.02) (xy 106.68 33.02))
     (stroke (width 0) (type default))
   )
@@
   )
   (wire (pts (xy 57.15 54.61) (xy 59.69 54.61))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 67.31 39.37) (xy 73.66 39.37))
     (stroke (width 0) (type default))
   )
@@
     )
   )
+  (global_label "CP_SENSE" (shape output) (at 82.55 39.37 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left))
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 95.0109 39.37 0)
+      (effects (font (size 1.27 1.27)) (justify left) hide)
+    )
+  )
   (global_label "3V3_uC" (shape input) (at 189.23 132.08 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right))
@@
     )
   )
-  (global_label "MODEM_RF" (shape input) (at 93.98 35.56 180) (fields_autoplaced)
+  (global_label "MODEM_RF" (shape input) (at 102.87 33.02 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 81.0957 35.56 0)
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 89.9857 33.02 0)
       (effects (font (size 1.27 1.27)) (justify right) hide)
     )
@@
     )
   )
-  (symbol (lib_id "Connector:Conn_01x02_Pin") (at 102.87 38.1 180) (unit 1)
+  (symbol (lib_id "Connector:Conn_01x02_Pin") (at 111.76 35.56 180) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "J7" (at 104.14 36.195 0)
-      (effects (font (size 1.27 1.27)) (justify right))
-    )
-    (property "Value" "RF" (at 104.14 38.735 0)
-      (effects (font (size 1.27 1.27)) (justify right))
-    )
-    (property "Footprint" "Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical" (at 102.87 38.1 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 102.87 38.1 0)
+    (property "Reference" "J7" (at 113.03 33.655 0)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Value" "RF" (at 113.03 36.195 0)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Footprint" "Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical" (at 111.76 35.56 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 111.76 35.56 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
-  (symbol (lib_id "power:GND") (at 97.79 38.1 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "#PWR048" (at 97.79 44.45 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "GND" (at 100.33 41.91 0)
-      (effects (font (size 1.27 1.27)) (justify right))
-    )
-    (property "Footprint" "" (at 97.79 38.1 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (at 97.79 38.1 0)
+  (symbol (lib_id "power:GND") (at 106.68 35.56 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "#PWR048" (at 106.68 41.91 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 109.22 39.37 0)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Footprint" "" (at 106.68 35.56 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 106.68 35.56 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
         )
       )
+    )
+  )
+  (symbol (lib_id "Device:R_Small") (at 76.2 39.37 270) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "R3" (at 76.2 34.29 90)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Value" "100k" (at 76.2 36.83 90)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder" (at 76.2 39.37 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "https://datasheet.lcsc.com/lcsc/1811101920_UNI-ROYAL-Uniroyal-Elec-0603WAF3301T5E_C22978.pdf" (at 76.2 39.37 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LCSC" "C22978" (at 76.2 39.37 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (instances
+      (project "qca7000"
+        (path "/e63e39d7-6ac0-4ffd-8aa3-1841a4541b55"
+          (reference "R3") (unit 1)
+        )
+        (path "/e63e39d7-6ac0-4ffd-8aa3-1841a4541b55/5666e7cf-6b6c-4583-8335-aa3be69ccd45"
+          (reference "R22") (unit 1)
+        )
+        (path "/e63e39d7-6ac0-4ffd-8aa3-1841a4541b55/539ec63d-ac7e-42ea-858e-ff2bf33430ea"
+          (reference "R58") (unit 1)
+        )
+      )

Commit message: added some jlcpcb part numbers, adjusted some footprints and values accordingly.
Parts:
- C17: LCSC C1679 -> C46653; LINK (none) -> https://jlcpcb.com/partdetail/47657-CL21B102KBCNNNC/C46653
- C17: LCSC tbd -> C49678; LINK (none) -> https://jlcpcb.com/partdetail/Yageo-CC0805KRX7R9BB104/C49678
- C17: LCSC tbd -> C1729; LINK (none) -> https://jlcpcb.com/partdetail/2081-CL21B223KBANNNC/C1729
- C61: LCSC C14663 -> C49678; LINK (none) -> https://jlcpcb.com/partdetail/Yageo-CC0805KRX7R9BB104/C49678
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "LCSC" "C14663" (at 270.51 135.89 90)
+    (property "LCSC" "C49678" (at 270.51 135.89 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/Yageo-CC0805KRX7R9BB104/C49678" (at 270.51 135.89 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "LCSC" "C1679" (at 66.04 26.67 0)
+    (property "LCSC" "C46653" (at 66.04 26.67 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/47657-CL21B102KBCNNNC/C46653" (at 66.04 26.67 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "LCSC" "tbd" (at 256.54 135.89 0)
+    (property "LCSC" "C49678" (at 256.54 135.89 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/Yageo-CC0805KRX7R9BB104/C49678" (at 256.54 135.89 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "LCSC" "tbd" (at 245.11 132.08 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "LCSC" "C1729" (at 245.11 132.08 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/2081-CL21B223KBANNNC/C1729" (at 245.11 132.08 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
