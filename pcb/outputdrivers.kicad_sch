File: pcb/outputdrivers.kicad_sch (KiCad schematic)
At the start: 32 parts, among them IC1 DRV8874QPWPRQ1, J7 CP/PE, J7 RF, Q1 BC846, Q2 NCV8402xST, Q3 NCV8402xST, Q4 DTA143Z, Q7 DTC114E, Q8 DTC114E, Q9 DTC114E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

Commit message: added more part numbers
Parts:
- D10: value 1N4148W -> B5819W; LCSC (none) -> C8598; LINK (none) -> https://jlcpcb.com/partdetail/9093-B5819WSL/C8598
- IC1: LCSC (none) -> C1855818; LINK (none) -> https://jlcpcb.com/partdetail/TexasInstruments-DRV8874PWPR/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
- Q1: LCSC (none) -> C3037601; LINK (none) -> https://jlcpcb.com/partdetail/Foshan_Blue_RocketElec-BC846/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
- Q2, Q3: LCSC (none) -> C236053; LINK (none) -> https://jlcpcb.com/partdetail/Onsemi-NCV8402ASTT3G/C236053
- Q4: LCSC (none) -> C2910150; LINK (none) -> https://jlcpcb.com/partdetail/3189169-DTA143ZCA/C2910150
- Q7, Q8, Q9: LCSC (none) -> C475671; LINK (none) -> https://jlcpcb.com/partdetail/Shikues-DTC114EE/C475671
- R3: footprint Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder -> Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC todo -> C28636; LINK (none) -> https://jlcpcb.com/partdetail/29388-0805W8F5600T5E/C28636
- R3: footprint Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder -> Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC todo -> C17557; LINK (none) -> https://jlcpcb.com/partdetail/18245-0805W8F2200T5E/C17557
- R3: footprint Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder -> Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C22978 -> C17557; LINK (none) -> https://jlcpcb.com/partdetail/18245-0805W8F2200T5E/C17557
- U7: LCSC (none) -> C672096; LINK (none) -> https://jlcpcb.com/partdetail/Nexperia-74HCT04D653/C672096
Changed lines of the file:
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@@
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LCSC" "C672096" (at 77.47 124.46 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/Nexperia-74HCT04D653/C672096" (at 77.47 124.46 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "LCSC" "C672096" (at 92.71 184.15 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/Nexperia-74HCT04D653/C672096" (at 92.71 184.15 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "LCSC" "C672096" (at 67.31 170.18 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/Nexperia-74HCT04D653/C672096" (at 67.31 170.18 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
+    (property "LCSC" "C475671" (at 214.63 87.63 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/Shikues-DTC114EE/C475671" (at 214.63 87.63 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
     )
     (property "Datasheet" "https://assets.nexperia.com/documents/data-sheet/74HC_HCT04.pdf" (at 35.56 187.96 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LCSC" "C672096" (at 35.56 187.96 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/Nexperia-74HCT04D653/C672096" (at 35.56 187.96 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
+    (property "LCSC" "C1855818" (at 199.39 127 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/TexasInstruments-DRV8874PWPR/C1855818" (at 199.39 127 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "10")
@@
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
+    (property "LCSC" "C475671" (at 236.22 87.63 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/Shikues-DTC114EE/C475671" (at 236.22 87.63 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder" (at 171.45 130.81 0)
+    (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder" (at 171.45 130.81 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "LCSC" "todo" (at 171.45 130.81 90)
+    (property "LCSC" "C28636" (at 171.45 130.81 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/29388-0805W8F5600T5E/C28636" (at 171.45 130.81 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (property "Datasheet" "" (at 227.33 58.42 0)
       (effects (font (size 1.27 1.27)) (justify left) hide)
+    )
+    (property "LCSC" "C2910150" (at 227.33 58.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/3189169-DTA143ZCA/C2910150" (at 227.33 58.42 0)
+      (effects (font (size 1.27 1.27)) hide)
     )
     (pin "1")
@@
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
+    (property "LCSC" "C3037601" (at 64.77 54.61 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/Foshan_Blue_RocketElec-BC846/C3037601" (at 64.77 54.61 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder" (at 229.87 68.58 0)
+    (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder" (at 229.87 68.58 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "LCSC" "todo" (at 229.87 68.58 90)
+    (property "LCSC" "C17557" (at 229.87 68.58 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/18245-0805W8F2200T5E/C17557" (at 229.87 68.58 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "LCSC" "C236053" (at 106.68 91.44 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/Onsemi-NCV8402ASTT3G/C236053" (at 106.68 91.44 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "LCSC" "C236053" (at 105.41 124.46 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/Onsemi-NCV8402ASTT3G/C236053" (at 105.41 124.46 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
     )
     (property "Datasheet" "https://assets.nexperia.com/documents/data-sheet/74HC_HCT04.pdf" (at 59.69 124.46 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LCSC" "C672096" (at 59.69 124.46 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/Nexperia-74HCT04D653/C672096" (at 59.69 124.46 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
+    (property "LCSC" "C475671" (at 259.08 87.63 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/Shikues-DTC114EE/C475671" (at 259.08 87.63 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
     )
     (property "Datasheet" "https://assets.nexperia.com/documents/data-sheet/74HC_HCT04.pdf" (at 76.2 91.44 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LCSC" "C672096" (at 76.2 91.44 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/Nexperia-74HCT04D653/C672096" (at 76.2 91.44 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
+    (property "LCSC" "C2910150" (at 247.65 58.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/3189169-DTA143ZCA/C2910150" (at 247.65 58.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder" (at 250.19 68.58 0)
+    (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder" (at 250.19 68.58 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "LCSC" "C22978" (at 250.19 68.58 90)
+    (property "LCSC" "C17557" (at 250.19 68.58 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/18245-0805W8F2200T5E/C17557" (at 250.19 68.58 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Value" "1N4148W" (at 59.69 34.925 90)
+    (property "Value" "B5819W" (at 59.69 34.925 90)
       (effects (font (size 1.27 1.27)) (justify right))
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "LCSC" "C8598" (at 57.15 33.02 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/9093-B5819WSL/C8598" (at 57.15 33.02 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
     (property "Datasheet" "" (at 267.97 58.42 0)
       (effects (font (size 1.27 1.27)) (justify left) hide)
+    )
+    (property "LCSC" "C2910150" (at 267.97 58.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/3189169-DTA143ZCA/C2910150" (at 267.97 58.42 0)
+      (effects (font (size 1.27 1.27)) hide)
     )
     (pin "1")
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder" (at 270.51 68.58 0)
+    (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder" (at 270.51 68.58 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "LCSC" "C22978" (at 270.51 68.58 90)
+    (property "LCSC" "C17557" (at 270.51 68.58 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/18245-0805W8F2200T5E/C17557" (at 270.51 68.58 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "LCSC" "C672096" (at 58.42 91.44 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LINK" "https://jlcpcb.com/partdetail/Nexperia-74HCT04D653/C672096" (at 58.42 91.44 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: more partnumbers assigned. split difficult values into two parts. add protection of CP_SENSE port
Parts:
- added D10: B5819W, Diode_SMD:D_SOD-123, symbol Diode:1N4148W
- R11: footprint Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder -> Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C25804 -> C17414; LINK (none) -> https://jlcpcb.com/partdetail/18102-0805W8F1002T5E/C17414
- R3: footprint Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder -> Resistor_SMD:R_0815_2038Metric_Pad1.20x4.05mm_HandSolder; LCSC C22978 -> C17379; LINK (none) -> https://jlcpcb.com/partdetail/18067-0805W8F1201T5E/C17379
- R3: footprint Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder -> Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C22978 -> C17530; LINK (none) -> https://jlcpcb.com/partdetail/18218-0805W8F2701T5E/C17530
- R3: footprint Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder -> Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC todo -> C17513; LINK (none) -> https://jlcpcb.com/partdetail/18201-0805W8F1001T5E/C17513
- R3: footprint Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder -> Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC todo -> C17530; LINK (none) -> https://jlcpcb.com/partdetail/18218-0805W8F2701T5E/C17530
- R3: footprint Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder -> Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C22978 -> C25270; LINK (none) -> https://jlcpcb.com/partdetail/26013-0805W8F1800T5E/C25270
- R3: footprint Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder -> Resistor_SMD:R_0815_2038Metric_Pad1.20x4.05mm_HandSolder; LCSC C22978 -> C149504; LINK (none) -> https://jlcpcb.com/partdetail/160838-0805W8F1003T5E/C149504
- R3: footprint Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder -> Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C22978 -> C17414; LINK (none) -> https://jlcpcb.com/partdetail/18102-0805W8F1002T5E/C17414
- R3: footprint Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder -> Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC todo -> C17414; LINK (none) -> https://jlcpcb.com/partdetail/18102-0805W8F1002T5E/C17414
Connections:
- net 3V3_uC: now also D10.1 (K)
- net CP_SENSE: now also D10.2 (A)
Other:
- note added: "According to data sheet stm32f103re.pdf, positive injection is not allowed, and max voltage on 5V tolerant pins is VDD+4V. So we limit the voltage here with diode to 3V3."
- moved on the sheet: J7

Commit message: footprint corrections. some layout adaptions for new footprints (ongoing)
Parts:
- R3: footprint Resistor_SMD:R_0815_2038Metric_Pad1.20x4.05mm_HandSolder -> Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "Resistor_SMD:R_0815_2038Metric_Pad1.20x4.05mm_HandSolder" (at 67.31 41.91 0)
+    (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder" (at 67.31 41.91 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "Resistor_SMD:R_0815_2038Metric_Pad1.20x4.05mm_HandSolder" (at 76.2 39.37 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Footprint" "Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder" (at 76.2 39.37 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: BOM consolidation: XTAL options and back to 8MHz. Replace internal connectors by testpoints. Use T with integrated R for CP switching. Fix: Footprint Q7-Q9 corrected.
Parts:
- removed J7: RF, Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical, symbol Connector:Conn_01x02_Pin
- removed J7: CP/PE, Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical, symbol Connector:Conn_01x02_Pin
- removed Q1: BC846, Package_TO_SOT_SMD:SOT-23, symbol Transistor_BJT:BC846
- removed R3: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, symbol Device:R_Small
- added INT (x2): ~, speciallib:TestPoint_Special_THTPad_D1.9mm_Drill1mm, symbol Connector:TestPoint
- added Q1: DTC114E, Package_TO_SOT_SMD:SOT-23, symbol Transistor_BJT:DTC114E
- Q7, Q8, Q9: LCSC C475671 -> C358500; LINK https://jlcpcb.com/partdetail/Shikues-DTC114EE/C475671 -> https://jlcpcb.com/partdetail/Foshan_Blue_RocketElec-DTC114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
Connections:
- net GND: now also INT.1, Q1.2 (E)
- net MODEM_RF: now also INT.1
- net STATE_C_CONTROL: now also Q1.1 (B)
- net at R3.1: now also Q1.3 (C)
Other:
- note added: "RF transformer, free-wired, no footprint"
