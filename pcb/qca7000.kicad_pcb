# Repository uhi22/foccci

File README.md (part):

# foccci - The Fully Open CCS Charge Controller Interface

 Hi, I'm Foccci. Just call me [Foksi] or [Fok-See] or just Foxi :-)
My real name is "Fully Open CCS Charge Controller Interface", but that's just too difficult to remember.

What I am? I'm a Charge Controller that enables CCS charging of homebrew electric vehicles.
I was born in the OpenInverter forum community, https://openinverter.org/forum/viewtopic.php?t=3727, and I'm growing more and more due to the great people there.
Inside, I have a QCA7005 PLC modem and an STM32 microcontroller. I'm a piece of hardware, and because hardware alone is quite boring,
I'm in a team with Clara, https://github.com/uhi22/ccs32clara, which is dealing with the bits and bytes of our mission. And together, we can do a lot for you.

# News

## 2024-06-27 Foccci Is Gaining Speed

While some folks are integrating Foccci in their vehicles and providing nice pictures for the galery (https://openinverter.org/forum/viewtopic.php?t=5077), we were proudly presenting the project at the
Augsburg Linux info day (https://openinverter.org/forum/viewtopic.php?t=4800). Sleep and wakeup,
new, fast contactor driver and a new connector pinout provide more flexibility for the car integration. That will
be the version 5, which will hopefully pop-up in the shop in July.

## 2023-12-13 Supercharging works. Halve a dozen boards are spread around the world. 

Johu is charging the Touran on the TESLA Supercharger using the hand-populated V3 board: https://openinverter.org/forum/viewtopic.php?p=64563#p64563 and https://www.youtube.com/watch?v=OKg3VUslol8
The first JLC populated boards have been completed manually, only one bug in the schematic needed a small workaround. Boards are on the way to several enthusiasts for further testing. The software is growing thanks to the great openinverter community.

## 2023-10-25 First Order of Populated Boards

Received four reservations on openinverter forum, and this was the trigger to create version v4.1 with minor layout
improvements, and to order a batch of five
at JLCPCB. Total cost for five: $127.32 including shipping, taxes and duties. The NCV8402 was out of stock,
and the QCA7005 is anyway not in their stock. So the material price is

- 25€ JLCPCB populated PCB
- 12€ QCA7005
- 4€ 2 x NCV8402
- 1€ RF transformator
- <1€ connectors for programming and serial line

## 2023-10-08 Light-Bulb-Demo-Charging on Alpitronic and ABB works

Using the foccci V3 board together with ccs32clara software, the muehlpower voltage sense board, a cheap chinese relay, the light-bulb-demo
worked on the first attempt on alpitronics hypercharger and on an ABB triple charger.

## 2023-07-28 Charging Loop Reached

The foccci board version 2023-07-12 runs the STM32F103 and the QCA7005, and successfully enters
the charging loop, with simulated evse by pyPLC. It provides the checkpoint number and some other
informations via CAN with 500kBaud. On the other side of the CAN sits an ESP32 Wifi-Kit-32, with
a CAN transceiver added. It shows the data of the CAN on its OLED display.

## 2023-07-09 The board starts talking

After the PCBs and QCAs arrived, the soldering was the next challenge. It went well, and the board started talking to
the ESP32 running ccs32berta https://github.com/uhi22/ccs32berta

https://openinverter.org/forum/viewtopic.php?p=58627#p58627

## 2023-06-21 First PCB with the QCA7005

...is ready in KiCad and is sent to JLCPCB. It is a two-layer, and has so many capacitors, that they do not really fit
to the place where they would make sense. Caused by taking the schematic from the Millisman design, but changing
the size to 1206 for easy hand soldering. Btw: Below five dollars for five PCBs, including shipping, duties and taxes.

## 2023-06-14 The Idea Is Born

...and the discussion is starting on the OpenInverter forum
https://openinverter.org/forum/viewtopic.php?p=57643#p57643

# Board versions

## V1 June 2023

- Just the QCA7005, exposing the SPI interface.
- No controller, no voltage regulator, no CP logic.
- Test result summary: Light-bulb-demo-charging works on alpitronics, with ccs32berta running on ESP32. (https://github.com/uhi22/ccs32berta)

## V2 2023-07-12

- STM32 controller
- Power supply
- CAN transceiver
- CP logic
- Two contactor drivers
- Test result summary: Light-bulb-demo-charging works on alpitronics, with ccs32clara https://github.com/uhi22/ccs32clara running on the STM32.  https://openinverter.org/forum/viewtopic.php?p=59821#p59821

## V3 2023-08-17

- HBridge driver DRV8874 for connector lock
- discrete drivers for RGB LEDs
- Deutsch Connector 2x12pins
- added CP and PP sensing
- changed from 2 layers to 4 layers
- Test result summary: The new output drivers work with https://github.com/uhi22/ccs32clara. Other tests still in progress.
- Issues:
    - Diode to 3V3 is missing in the CP sense path (R58). Need to be patched.
    - There is a via near the pin1-corner of the QCA, which is very near to the metal frame at the corner, and may cause shortcut between 1V2 and ground.

## V4 2023-09-10

- Prepared for assembling by JLCPCB
- No 1206 size components anymore. Means: 0805 is the new default size now.
- Test result summary: PCBs not ordered yet. No testing done yet.
- Outdated, never produced.

## V4.1 2023-10-25

- functionally identical to V4
- moved via away from QCA corner to avoid solder bridge
- silk screen improvements: more component names and better readability
- Test result summary: one issue found (shortcut on the RX inputs to ground via inductors). After fixing this, everything works fine.

## V4.2 2024-02-06

- rx path grounding bug resolved
- added RF transformer
- proximity pilot input circuit corrected (330ohm pull-up to 5V instead of 1k to 3.3V)
- hardware variant coding with two resistors on analog port added
- routed the current measurement pin of the lock driver DRV8874 (IPROPI) to the ADC
- more copper cooling area for the contactor drivers
- more spare holes
- added openinverter logo - and lost it later when transferring the schematics update to the PCB - sorry
- added mounting holes
- layout optimizations, footprint and part number corrections
- Issues:
    - R56 (PP pull-up) has 33ohms instead of intended 330ohms. Wrong part number C17634.
    - missing track between D4 and D7
    - missing tracks on C39 (IPROPI)
    - missing track on R63 (IPROPI)
    - missing tracks on R28 (ADC_PP)
    - missing ground on R60 (PP_PULLDOWN)

These are the patches:

## V4.3

fixes the issues of the 4.2

## V4.5

- contactor driver is now the same, fast as the lock motor driver
- wakeup logic added

## V4.5b

First version with the changed connector pinout. Intermediate version, never produced.

## V5

Functionally identical with V4.5b. The first official version with the new connector pinout.
- layout fixes (missing connection D20, clearance violations, courtyard violations)
- QCA JTAG preparation
- Added openinverter and Foccci logos

- Issues
    - enable pin of the step-down gets battery voltage, which leads to current draw
    - wrong resistor values R52 and R64 in the BOM

## V5.1

- added D8 at the enable pin of the step-down, to avoid unintended current flow
- removed spare capacitors on the crystal from schematic
- propagated the 1k values of R52 and R64 to the board
- fixed some rotations

## V5.2pre

- removed the RF transformer including symmetric parts of the RX and TX path
- added fast TVS for protection of RF path
- three mounting holes changed from 3.2mm to 3.5mm
- demo placement for alternative 2.54mm headers (not routed, lot of DRC violations!!!)

# Background

The QCA7005 schematic and board was originally designed by Millisman https://github.com/Millisman/QCA7000, then forked to https://github.com/uhi22/QCA7000board and then renamed to https://github.com/uhi22/foccci

# Changes to the original Millisman design

## Schematic
- removed JTAG completely
- removed connector for SPI flash, added testpoints instead

- ATP_P and ATP_N are reserved analog test points. Leave unconnected without testpoints.
- ZC_IN connected to ground. Not used.
- PLL_BYPASS has an internal pulldown. Removed the external pulldown.
- Removed the LEDs on the GPIO.
- RSVD06 and 07 are "do not connect". Removed the test points.
- Bugfix: The ground was missing between C13 and C14.

## symbol QCA7000:
 - RSVD01 changed to power_in, because connected to 3.3V
 - RSVD04 changed to power_in, because connected to 1.2V
 - TCK changed from output to input, because this is the test clock driven by debugger. Even if the data sheet says "output".
 
## Footprints in Schematic

- changed the 100nF to 1206 for easy handsoldering (and back to 0805 for some, to safe space)
- changed the 10µF to 1210
- changed other 0603 Cs to 0805
- changed L and Rs to 1206 (and the beads back to 0805)

## Todos for now

[ ] Footprint for L13 leads to complains of JLC, see https://openinverter.org/forum/viewtopic.php?p=72630#p72630

## Todos for Later

- [ ] add optional "Molex Mini-Fit Jr. Header, Dual Row" for the case, that the Deutsch is not needed in certain use cases.
- [ ] Docu: add details of step-by-step bring-up, incl current consumption, and typical errors
- [ ] more temperature inputs (6, to support L1, L2, L3, N, DC+ and DC-)
- [ ] The use of the LEDs on GPIO0 to 3 is not clear. Are they used in the automotive firmware at all? GPIO3: on the CCM, this is connected to µC.43 via R8 (0 ohms). Measure the pin.
- [ ] Regarding AMS1117-3.3 for the 3v3 regulators. These are tried and tested, but you may wish to avoid the polarized capacitor by using a more modern regulator. Consider TLV75733PDBV "Stable With a 1-μF Ceramic Output Capacitor"
- [ ] The STM32F103 seems to meet the requirements and it's popular but be aware that it has a basic ARM core with no FPU. And: Do we need a low-power variant (stm32L4 series)?
- [ ] The QCA7005 is labelled QCA7000.
- [ ] missing the JTAG port pull down resistors on the QCA
- [ ] Could do with one more processor decoupler so that a cap can be dropped right against every package power pin.
- [ ] Would be worth adding lines to the QCA7005 Reset (so that is can be reset without a power cycle) and the Int pins (just in case it's needed in the future).
- [ ] Might put a Schottky protection diode on the temperate sense inputs.
- [ ] supply voltage measurement (to be able to adjust the PWM for contactors according to the supply voltage, and just for info)

## Finished Todos
- [x] TVS at the CP
- [x] Transformerless RF path
- [x] do not inject >7V into the enable pin of the step-down
- [x] Low-power concept
- [x] Clarify interface (electrically and mechanically)
- [x] more copper cooling area for the NCVs
- [x] analog current feedback from the DRV8874 IPROPI to the controller
- [x] Add a version indication analog circuit. Discussed here: https://openinverter.org/forum/viewtopic.php?p=66745#p66745
- [x] Change the PP pull-up to 330 ohms and 5V, and optionally prepare pull-down 2k7. Use voltage divider to the controller, to be able to measure the full 0 to 5V range. Discussion here: https://openinverter.org/forum/viewtopic.php?p=66208#p66208

- [x] For C69, how to workaround the forced switch from "economy" to "standard" service? Workaround: use C3445244, discussed here: https://openinverter.org/forum/viewtopic.php?p=65016#p65016
- [x] Remove DC-grounding of the RX inputs. Done: C32 and C33 added on the RX inputs.
- [x] Transformer (discussion here: https://openinverter.org/forum/viewtopic.php?p=64465#p64465) see https://jlcpcb.com/partdetail/3170710-CL4532A201/C2904734 Done: Added into new lib transformerCL4532A-201 and to schematic and pcb.
- [x] Adapt the part number for the NCV8402 (discussed here: https://openinverter.org/forum/viewtopic.php?p=62903#p62903). Done: Part number C77755 instead of C236053
- [x] Adapt the footprints / part numbers for the parts which JLC could not populate
    - [x] U1 Flash: Old: Package_SO:SOP-8_5.28x5.23mm_P1.27mm, must be SOIC 150mil (order code SN), which is Package_SO:SOIC-8_3.9x4.9mm_P1.27mm.
    - [x] L11: The https://jlcpcb.com/partdetail/C162588 is normal 1206. Changed from Inductor_SMD:L_1812_4532Metric_Pad1.30x3.40mm_HandSolder to Inductor_SMD:L_1206_3216Metric_Pad1.22x1.90mm_HandSolder
- [x] Add additional mounting holes
- [x] Stepdown layout optimization (discussed here: https://openinverter.org/forum/viewtopic.php?p=61697#p61697), including smaller L, e.g. https://jlcpcb.com/partdetail/LantuMicro-SMS1050100MT/C5127462 instead of C3000379. And, next step, even smaller
https://jlcpcb.com/partdetail/Sunlord-MWSA0503S100MT/C408412 is 5.1 x 5.4mm.
- [x] TVS at the 12V. SMAJ18A
- [x] move as much as possible bottom layer components to upper layer, to allow population by JLBPCB
- [x] adapt layout for changed footprints
- [x] check/remove/correct the JLCPCB part numbers for all parts. Most parts now 0805.
- [x] add protection diode for CP sense
- [x] CP sensing
- [x] 5V on the connector for supply of the muehlpower high voltage sense board
- [x] Clarify expected contactor current and use appropriate drivers
- [x] Footprints for the bigger capacitors too small. -> Use 1210 for C65, C66, C67, 
- [x] Many texts in the silk screen are not readable due to overlap with solder or components
- [x] Some of the many capacitors on the supply lines could be removed
- [x] Use 0805 for all 100nF, instead of mixing 0805 and 1206.
- [x] The EN pin of the CAN transceiver should have the flexibility to solder-bridge to GND and 3V3, to allow different type of transceivers.
- [x] Change footprint of the test points for flash programming, so that squared connector pins fit into.
- [x] highside LED drivers for RGB button
- [x] VDDA of the STM32 needs additional 1µF according to STM application note AN2834. https://www.st.com/resource/en/application_note/an2834-how-to-get-the-best-adc-accuracy-in-stm32-microcontrollers-stmicroelectronics.pdf chapter 4.2.1 -> C14 added.
- [x] add port locking driver
- [x] Complete the schematic and the layout for the DRV8874 h-bridge driver
- [x] add PP detection
- [x] change to 4 layers
- [x] One of your AMS1117 seems to have a 100nF output cap and the other doesn't.
- [x] 470u input cap is an electrolytic? Yes.
- [x] Which connector? DTM13-12PA-12PB-R008 https://openinverter.org/forum/viewtopic.php?p=58697#p58697
- [x] HCT04: Risk of activating the contactors if the controller power fails. Find a better solution.
- [x] Check boot config on GPIO 0 to 2.
    - [x] GPIO0: High during boot to boot from the SPI Flash. (pin60) CCM: R9 is 3k3 to 3V3.
    - [x] GPIO1: must be pulled low during reset. (pin61) CCM: R11 is 3k3 to ground.
    - [x] GPIO2: 0=legacy SPI, 1=burst SPI. Which is used in the CCM? (pin62) CCM: R10 is 3k3 to 3V3, and the not-populated R27 into direction of µC.
        - [x] connect the GPIO2 with pullup to 3V3
- [x] add LEDs for functional check
- [x] add mounting holes
- [x] correct voltage divider in the TPS54302
- [x] 3V3_uC and NRST on connectors for debugger
- [x] removed the wrong part number and datasheet for the 8MHz XTAL
- [x] larger footprint for L10: From 1206 to 1812
- [x] check all pins -> all plausible with the data sheet.
- [x] check the QCA footprint -> fits.
- [x] assign footprint to all components in the schematic
- [x] add CP logic
- [x] add microcontroller
- [x] add power supply
- [x] add contactor driver outputs
- [x] add port temperature sensor inputs
- [x] Takeover from CCM:
   - [x] RBIAS (pin 51, R9). In the CCM this is R19 with 2,5k. Used 3k || 15k, this is exactly 2k5.
   - [x] BIAS_REF (pin 40, R6). In the CCM this is R23 with 6,2k. -> Changed from 2k5 to 6k2 in the schematic. Populated 6k8.
- [x] What's going on with the missing processor Gnd pins, are they mapped within the part? Yes, in the layout they are correct.
- [x] Add LIM-like current input for HVDC voltage measuring, https://openinverter.org/forum/viewtopic.php?p=58839#p58839

# Interface

...is described in the wiki: https://openinverter.org/wiki/Foccci
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
## KiCad design pcb/qca7000.kicad_pcb

Parts:
3V3: TestPoint_Special_THTPad_D1.9mm_Drill1mm
C1, C4, C5, C32, C33: 1.5nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C1717
C2, C3, C10: 220pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C107145
C9, C11, C13, C16, C28, C31, C34, C35, C37, C38, C40, C42, C43, C44, C45, C46, C47, C48, C49, C50, C51, C52, C53, C55: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C49678
C17, C29: 6.8pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C1679
C19, C22, C24, C26, C30, C36: 10uF 25V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C15850
C76: 1nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C46653
CLK1: TestPoint_Special_THTPad_D1.9mm_Drill1mm
CS1: TestPoint_Special_THTPad_D1.9mm_Drill1mm
D2: BAV99; SOT-23; LCSC C2500
D3, D4: B5819W; D_SOD-123; LCSC C8598
D5: 3V9; D_SMA; LCSC C438352
GND1: TestPoint_Special_THTPad_D1.9mm_Drill1mm
INT1: TestPoint_Special_THTPad_D1.9mm_Drill1mm
J1: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
L1: 270nH; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder; LCSC C281081
L2, L9, L10: Bead 600; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C1017
L3, L4, L5: 1.8uH; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C78153
L11: 4.7uH; L_1206_3216Metric_Pad1.22x1.90mm_HandSolder; LCSC C162588
MISO1: TestPoint_Special_THTPad_D1.9mm_Drill1mm
MOSI1: TestPoint_Special_THTPad_D1.9mm_Drill1mm
R1: 22; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17561
R3, R4: 3.3K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C26010
R5: 33; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17634
R6: 6k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C4260
R7, R10: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17414
R8, R25: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17408
R9: 2.2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17520
R59: 330; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C23138
RES1: TestPoint_Special_THTPad_D1.9mm_Drill1mm
TP1: 1V2; TestPoint_Pad_D1.0mm
TP2: TXOUTP; TestPoint_Pad_D1.0mm
U1: 25Q16; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C115407
U7: QCA 7000; QFN-68-1EP_8x8mm_P0.4mm_EP5.2x5.2mm_ThermalVias; LCSC C9900078626
U9: DESD3V3S1BL-7B; X1-DFN1006-2_RH_DIO; LCSC C500765
Y1: 25MHz; Crystal_SMD_TXC_7M-4Pin_3.2x2.5mm; LCSC C9006

Connections:
3V3_D: 3V3.1, C22.2, C24.2, C30.2, C35.1, C37.2, C42.1, C43.1, C45.2, C47.1, C55.2, L2.2, L9.2, R4.2, R7.2, R10.2, U1.3 (~WP/IO2), U1.7 (~HOLD/IO3), U1.8 (VCC), U7.2 (DVDD), U7.6 (DVDD), U7.7 (SW_DVDD_IN), U7.8 (SW_DVDD_IN), U7.13 (DVDD), U7.17 (DVDD), U7.21 (DVDD), U7.43 (DVDD), U7.47 (RSVD01), U7.59 (DVDD), U7.64 (DVDD); also elsewhere on the board
+1V2_C: C16.2, C26.2, C34.2, C36.1, C38.1, C40.2, C48.1, C49.1, C50.2, C52.2, C53.2, L10.2, L11.2, TP1.1, U7.1 (VDD), U7.4 (VDD), U7.11 (VREG_SWREG_FB), U7.12 (VDD), U7.18 (VDD), U7.28 (VDD), U7.42 (VDD), U7.45 (VDD), U7.46 (VDD), U7.50 (RSVD04), U7.57 (RSVD08), U7.58 (VDD), U7.68 (VDD)
+3V3_A: C19.2, C28.1, L2.1, L3.2, U7.32 (DVDDHLD), U7.36 (XTAL_DVDD)
/RBIAS: R9.1, U7.51 (RBIAS)
/RSVD05: C51.2, U7.48 (RSVD02), U7.52 (RSVD05)
/SW_VDD_OUT: L11.1, U7.9 (SW_VDD_OUT), U7.10 (SW_VDD_OUT)
AVDD: C31.2, L10.1, U7.39 (AVDD)
BIASREF: R6.1, U7.40 (BIASREF)
CP: C76.1; also elsewhere on the board
GND: C2.2, C3.2, C4.1, C5.1, C10.2, C11.1, C13.1, C16.1, C17.1, C19.1, C22.1, C24.1, C26.1, C28.2, C29.1, C30.1, C31.1, C33.2, C34.1, C35.2, C36.2, C37.1, C38.2, C40.1, C42.2, C43.2, C44.2, C45.1, C46.1, C47.2, C48.2, C49.2, C50.1, C51.1, C52.1, C53.1, C55.1, D2.1 (K), D3.2 (A), D5.2 (A), GND1.1, J1.6, L4.2, L5.2, R3.2, R6.2, R59.2, U1.4 (GND), U7.22 (TDI), U7.23 (TCK), U7.25 (TMS), U7.27 (TRST_L), U7.41 (ZC_IN), U7.55 (GND), U7.56 (GND), U7.69 (GND), U9.2, Y1.2, Y1.4; also elsewhere on the board
GPIO_1: R3.1, U7.61 (GPIO_1)
GPIO_2: R4.1, U7.62 (GPIO_2)
unnamed: C1.1, L1.1
unnamed: C1.2, C2.1, L4.1, R1.1
unnamed: C3.1, C32.2, D2.3 (K), L1.2, L5.1
unnamed: C9.2, C10.1, R8.1
unnamed: C29.2, R5.1, Y1.3
unnamed: C76.2, R25.2
unnamed: C4.2, C5.2, D2.2 (A), L3.1
unnamed: C11.2, C13.2, D4.1 (K), D5.1 (K), L9.1
unnamed: R9.2, R59.1
unnamed: C46.2, U7.49 (RSVD03)
unnamed: TP2.1, U7.33 (TXOUT_P)
unnamed: C17.2, U7.37 (XTAL_IN), Y1.1
unnamed: R5.2, U7.38 (XTAL_OUT)
RESET#: C44.1, J1.5, R10.1, RES1.1, U7.5 (RESET_L)
RF_protected: R1.2, R8.2, R25.1, U9.1
RXIN_N: C32.1, U7.29 (RXIN_N)
RXIN_P: C33.1, U7.30 (RXIN_P)
SERIAL_IO_0_INT: INT1.1, U7.20 (SERIAL_IO[0])
SERIAL_IO_1_CLK: CLK1.1, U7.19 (SERIAL_IO[1]); also elsewhere on the board
SERIAL_IO_2_CS: CS1.1, U7.16 (SERIAL_IO[2]); also elsewhere on the board
SERIAL_IO_3_MISO: MISO1.1, U7.15 (SERIAL_IO[3]); also elsewhere on the board
SERIAL_IO_4_MOSI: MOSI1.1, U7.14 (SERIAL_IO[4]); also elsewhere on the board
SPI_CLK: J1.4, U1.6 (SCK), U7.67 (SPI_CLK)
SPI_CS_L: J1.2, R7.1, U1.1 (~CS), U7.65 (SPI_CS_L)
SPI_DI: J1.1, U1.2 (SO/IO1), U7.3 (SPI_DI)
SPI_DO: J1.3, U1.5 (SI/IO0), U7.66 (SPI_D0)
TXOUT_N: C9.1, D3.1 (K), D4.2 (A), U7.31 (TXOUT_N)

Notes on the sheet:
2k5
With 3.3V TVS and input divider R25 we allow >12Vpp on CP line without saturation.
1N5819HW 2pcs
Atmel AT26DF161-SU 100 MHz 16-Mbits Not for new designs Atmel AT26DF161A-SU 70 MHz 16-Mbits Numonyx M25P80-VMW6TP 75 MHz 8-Mbits Numonyx M25P16-VMW6TP 75MHz 16-Mbits Macronix MX25L8005 70 MHz 8-Mbits Macronix MX25L1605 86 MHz 16-Mbits
GPIO_2 selects burst mode (3V3)
ARM926
3rd Order Butterworth Bandpass Lower Cutoff Freq. = 1.900 MHz; Upper Cutoff Freq. = 31.00 MHz https://rf-tools.com/lc-filter/
M25P16
GPIO_1 must be pulled down.
25q16

Parts:
H1, H2, H4: MountingHole; MountingHole_3.5mm_Pad
J2, J3, J4, J5: Conn_01x06_Pin; PinHeader_1x06_P2.54mm_Vertical
J20: DTM1312PA12PBR008; TE_DTM1312PA12PBR008; PARTREV E; not fitted
U8: EEC-325X4B; TE_EEC-325X4B; PARTREV F

Connections:
5V: J4.3, J20.B11; also elsewhere on the board
12V: J4.6, J20.B8; also elsewhere on the board
BUTTON: J3.3, J20.A7; also elsewhere on the board
CANH: J4.1, J20.B1; also elsewhere on the board
CANL: J4.2, J20.B2; also elsewhere on the board
CONN_LOCK_FEEDBACK: J3.1, J20.A4; also elsewhere on the board
CONN_LOCK_MOT1: J3.5, J20.A9; also elsewhere on the board
CONN_LOCK_MOT2: J3.6, J20.A8; also elsewhere on the board
CONTACTOR1_LS: J5.1, J20.B6; also elsewhere on the board
CONTACTOR2_LS: J4.5, J20.B4; also elsewhere on the board
CP: J3.4, J20.A6; also elsewhere on the board
GND: J5.3, J5.4, J5.5, J5.6, J20.B3, J20.B5, J20.B9, J20.B12; also elsewhere on the board
IN_U_HV: J4.4, J20.B10; also elsewhere on the board
LED_BLUE: J2.6, J20.A10; also elsewhere on the board
LED_GREEN: J2.4, J20.A11; also elsewhere on the board
LED_RED: J2.2, J20.A12; also elsewhere on the board
PP: J3.2, J20.A5; also elsewhere on the board
TEMP1: J2.1, J20.A1; also elsewhere on the board
TEMP2: J2.3, J20.A2; also elsewhere on the board
TEMP3: J2.5, J20.A3; also elsewhere on the board
WAKEUP: J5.2, J20.B7; also elsewhere on the board

Notes on the sheet:
The enclosure, black, no vent, https://www.te.com/usa-en/product-EEC-325X4B.html
Alternative connectors: 4 pieces 6 pin header
5V for the high-voltage measurement module.
The connector, 2 x 12 pins, https://www.te.com/usa-en/product-DTM1312PA12PBR008.html

Parts:
C15, C72: 22nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C1729
C18, C25, C39, C75, C81: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C49678
C54, C69, C70: 22uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder; LCSC C12891
D14, D16: B5819W; D_SOD-123; LCSC C8598
IC1, IC2: DRV8874QPWPRQ1; SOP65P640X120-17N; Mouser Part Number 595-DRV8874QPWPRQ1
Q1, Q7, Q8, Q12, Q13: 2N7002; SOT-23; LCSC C8545
Q4, Q5, Q6: DTA143Z; SOT-23; LCSC C2910150
Q11: AO3401A; SOT-23; LCSC C15127
R26, R30, R51: 2k7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17530
R27: 1k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17379
R29, R50: 560; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C28636
R45, R46, R47: 220; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17557
R48: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17513
R49, R69: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17414
R58: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C149504
R63: 47k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17713

Connections:
3V3_uC: D16.1 (K), IC1.3 (NSLEEP), R29.2, R49.2, R50.2; also elsewhere on the board
12V_P: C18.2, C25.2, C54.2, C69.2, C70.2, C75.2, C81.1, IC1.11 (VM), IC2.11 (VM), Q4.2 (E), Q5.2 (E), Q6.2 (E), Q11.2 (S), R69.2; also elsewhere on the board
ADC_IPROPI: C39.2, R63.1; also elsewhere on the board
CONN_LOCK_MOT1: IC1.8 (OUT1); also elsewhere on the board
CONN_LOCK_MOT2: IC1.10 (OUT2); also elsewhere on the board
CONTACTOR1_LS: IC2.8 (OUT1); also elsewhere on the board
CONTACTOR2_LS: IC2.10 (OUT2); also elsewhere on the board
CONTACTOR_CONTROL1: IC2.1 (EN/IN1); also elsewhere on the board
CONTACTOR_CONTROL2: IC2.2 (PH/IN2); also elsewhere on the board
CONTACTOR_ENABLE: IC2.3 (NSLEEP); also elsewhere on the board
CP: D14.2 (A); also elsewhere on the board
CP_SENSE: D16.2 (A), R58.1; also elsewhere on the board
DRV_FAULT: IC1.4 (NFAULT), IC2.4 (NFAULT), R49.1; also elsewhere on the board
DRV_IN1: IC1.1 (EN/IN1); also elsewhere on the board
DRV_IN2: IC1.2 (PH/IN2); also elsewhere on the board
GND: C25.1, C39.1, C54.1, C69.1, C70.1, C81.2, IC1.7 (IMODE), IC1.9 (PGND), IC1.15 (GND), IC1.17 (EP), IC2.7 (IMODE), IC2.9 (PGND), IC2.15 (GND), IC2.17 (EP), Q1.2 (S), Q7.2 (S), Q8.2 (S), Q12.2 (S), Q13.2 (S), R26.1, R30.2, R48.1, R51.1; also elsewhere on the board
LED_BLUE: R47.1; also elsewhere on the board
LED_CTL_BLUE: Q8.1 (G); also elsewhere on the board
LED_CTL_GREEN: Q7.1 (G); also elsewhere on the board
LED_CTL_RED: Q12.1 (G); also elsewhere on the board
LED_GREEN: R46.1; also elsewhere on the board
LED_RED: R45.1; also elsewhere on the board
unnamed: D14.1 (K), R26.2, R27.2, R58.2
unnamed: C15.2, IC1.13 (CPH)
unnamed: C15.1, IC1.14 (CPL)
unnamed: IC1.6 (IPROPI), R48.2, R63.2
unnamed: C18.1, IC1.12 (VCP)
unnamed: IC1.5 (VREF), R50.1, R51.2
unnamed: C72.2, IC2.13 (CPH)
unnamed: C72.1, IC2.14 (CPL)
unnamed: C75.1, IC2.12 (VCP)
unnamed: IC2.5 (VREF), R29.1, R30.1
unnamed: Q1.3 (D), R27.1
unnamed: Q4.3 (C), R45.2
unnamed: Q5.1 (B), Q7.3 (D)
unnamed: Q5.3 (C), R46.2
unnamed: Q6.1 (B), Q8.3 (D)
unnamed: Q6.3 (C), R47.2
unnamed: Q11.1 (G), Q13.3 (D), R69.1
unnamed: Q4.1 (B), Q12.3 (D)
STATE_C_CONTROL: Q1.1 (G); also elsewhere on the board
TRIGGER_WAKEUP: Q13.1 (G); also elsewhere on the board
WAKEUP: Q11.3 (D); also elsewhere on the board

Notes on the sheet:
IMode=GND leads to Fixed Off-time and automatic retry
IPROPI is 450µA/A. With 6A peak output this is 2.7mA. With R=1k we get 2.7V for the 6A. On VREF, we have 3.3V divided by 560 ohms and 2k7, this results in 2.73V. This means, the current limitation will jump in when the output current is above 6A.
According to data sheet stm32f103re.pdf, positive injection is not allowed, and max voltage on 5V tolerant pins is VDD+4V. So we limit the voltage here with diode to 3V3.
No extra TVS necessary on CP, because: - The stateC transistor is self protecting (avalance and reverse diode, and serial resistor) - The measurement has clamping and series resistor. - The RF part has TVS behind series resistor.
12V highside outputs for the LEDs in the button. (or low-current-general-purpose)
ControlPilot circuit for StateB (2k7) and StateC (additional 1k2).
We reuse DRV_FAULT from the lock driver. Since software should know which device it last acted it will also know which one caused the fault
PMode=open leads to independent control of both half bridges
The bulk capacitor is especially important when switching high currents, see DRV8874 data sheet.
Series resistors to protect the output in case of short circuit. With 12V and 220ohms we get 54mA and 0.6W. This may burn the resistors after a short time, but better than burning the transistors.
The DRV is not specified for inverse polarity. So we need the protected 12V here.
