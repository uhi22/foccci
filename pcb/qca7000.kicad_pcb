# Repository uhi22/foccci (continued)

## KiCad design pcb/qca7000.kicad_pcb (continued)

Parts:
3V3_uC1: TestPoint_Special_THTPad_D1.9mm_Drill1mm
C14: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C28323
C56, C57, C58, C59, C60, C61: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C49678
C62, C63: 22pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C1804
D9: PWR; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C2296
D10: ALIVE; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C2296
D11: STATEC; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C2296
D12: CONTACTOR1; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C2296
D15: UARTTX; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C2296
JP1: EN_LOW; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
JP2: EN_HIGH; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
L12: Bead 600; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C1017
PB5, PB6, PB12, PB13: TestPoint_THTPad_D1.0mm_Drill0.5mm
R11, R12, R13, R14, R21, R22: 220; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17557
R15: 33; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17634
R16, R17, R18, R19, R20, R37: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17513
SWCLK1: TestPoint_Special_THTPad_D1.9mm_Drill1mm
SWDIO1: TestPoint_Special_THTPad_D1.9mm_Drill1mm
SWGND1: TestPoint_Special_THTPad_D1.9mm_Drill1mm
SWO1: TestPoint_Special_THTPad_D1.9mm_Drill1mm
TP3, TP4: TestPoint; TestPoint_Special_THTPad_D1.9mm_Drill1mm
TP11, TP12, TP13, TP14, TP26, TP27, TP28, TP29, TP30, TP31, TP38: TestPoint_THTPad_D1.0mm_Drill0.5mm
U2: SN65HVD230; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C12084
U3: STM32F103RETx; LQFP-64_10x10mm_P0.5mm; LCSC C8322
UART_GND1: TestPoint_Special_THTPad_D1.9mm_Drill1mm
UART_RX1: TestPoint_Special_THTPad_D1.9mm_Drill1mm
UART_TX1: TestPoint_Special_THTPad_D1.9mm_Drill1mm
Y2: 8MHz; Crystal_SMD_TXC_7M-4Pin_3.2x2.5mm; LCSC none
Y3: 8MHz; Crystal_SMD_5032-2Pin_5.0x3.2mm; LCSC C115962
uC_NRST1: TestPoint_Special_THTPad_D1.9mm_Drill1mm

Connections:
3V3_uC: 3V3_uC1.1, C56.2, C57.2, C58.2, C59.2, D15.2 (A), JP2.2 (B), L12.2, R17.1, U2.3 (VCC), U3.1 (VBAT), U3.19 (VDD), U3.32 (VDD), U3.48 (VDD), U3.64 (VDD); also elsewhere on the board
/controller/OCS_IN: C62.1, U3.5 (PD0), Y2.1, Y3.2
/controller/OSC_OUT: R15.2, U3.6 (PD1)
ADC123_IN10: U3.8 (PC0); also elsewhere on the board
ADC123_IN11: U3.9 (PC1); also elsewhere on the board
ADC123_IN12: U3.10 (PC2); also elsewhere on the board
ADC_BUTTON: U3.24 (PC4); also elsewhere on the board
ADC_CONN_LOCK_FEEDBACK: U3.25 (PC5); also elsewhere on the board
ADC_HWVARIANT: U3.16 (PA2); also elsewhere on the board
ADC_IPROPI: U3.17 (PA3); also elsewhere on the board
ADC_PP: U3.14 (PA0); also elsewhere on the board
ADC_U_HVDC: U3.11 (PC3); also elsewhere on the board
CANH: R16.2, U2.7 (CANH); also elsewhere on the board
CANL: R16.1, U2.6 (CANL); also elsewhere on the board
CAN_EN: JP1.1 (A), JP2.1 (A), U2.5 (EN)
CAN_RX: U2.4 (R), U3.44 (PA11)
CAN_TX: U2.1 (D), U3.45 (PA12)
CONTACTOR_CONTROL1: R20.1, U3.39 (PC8); also elsewhere on the board
CONTACTOR_CONTROL2: U3.40 (PC9); also elsewhere on the board
CONTACTOR_ENABLE: U3.15 (PA1); also elsewhere on the board
CP_SENSE: U3.50 (PA15); also elsewhere on the board
DRV_FAULT: U3.35 (PB14); also elsewhere on the board
DRV_IN1: U3.37 (PC6); also elsewhere on the board
DRV_IN2: U3.38 (PC7); also elsewhere on the board
GND: C14.1, C56.1, C57.1, C58.1, C59.1, C60.1, C61.1, C62.2, C63.1, D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), JP1.2 (B), SWGND1.1, U2.2 (GND), U2.8 (Rs), U3.12 (VSSA), U3.18 (VSS), U3.31 (VSS), U3.47 (VSS), U3.60 (BOOT0), U3.63 (VSS), UART_GND1.1, Y2.2, Y2.4; also elsewhere on the board
KEEP_POWER_ON: U3.27 (PB1); also elsewhere on the board
LED_ALIVE: R18.1, U3.59 (PB7)
LED_CTL_BLUE: TP4.1, U3.30 (PB11); also elsewhere on the board
LED_CTL_GREEN: TP3.1, U3.29 (PB10); also elsewhere on the board
LED_CTL_RED: U3.28 (PB2); also elsewhere on the board
unnamed: C63.2, R15.1, Y2.3, Y3.1
unnamed: D9.2 (A), R17.2
unnamed: D10.2 (A), R18.2
unnamed: D11.2 (A), R19.2
unnamed: D12.2 (A), R20.2
unnamed: D15.1 (K), R37.2
unnamed: R21.2, UART_TX1.1
unnamed: R22.2, UART_RX1.1
unnamed: TP12.1, U3.41 (PA8)
unnamed: TP13.1, U3.42 (PA9)
unnamed: TP14.1, U3.43 (PA10)
unnamed: PB5.1, U3.57 (PB5)
unnamed: PB6.1, U3.58 (PB6)
unnamed: TP30.1, U3.61 (PB8)
unnamed: TP31.1, U3.62 (PB9)
unnamed: PB12.1, U3.33 (PB12)
unnamed: PB13.1, U3.34 (PB13)
unnamed: TP38.1, U3.36 (PB15)
unnamed: TP26.1, U3.53 (PC12)
unnamed: TP27.1, U3.2 (PC13)
unnamed: TP28.1, U3.3 (PC14)
unnamed: TP29.1, U3.4 (PC15)
unnamed: TP11.1, U3.54 (PD2)
unnamed: C14.2, C61.2, L12.1, U3.13 (VDDA)
SERIAL_IO_1_CLK: R12.2; also elsewhere on the board
SERIAL_IO_2_CS: R11.2; also elsewhere on the board
SERIAL_IO_3_MISO: R13.2; also elsewhere on the board
SERIAL_IO_4_MOSI: R14.2; also elsewhere on the board
SPI1_CLK: R12.1, U3.21 (PA5)
SPI1_MISO: R13.1, U3.22 (PA6)
SPI1_MOSI: R14.1, U3.23 (PA7)
SPI1_NSS: R11.1, U3.20 (PA4)
STATE_C_CONTROL: R19.1, U3.56 (PB4); also elsewhere on the board
SWCLK: SWCLK1.1, U3.49 (PA14)
SWDIO: SWDIO1.1, U3.46 (PA13)
SWO: SWO1.1, U3.55 (PB3)
TRIGGER_WAKEUP: U3.26 (PB0); also elsewhere on the board
UART4_RX: R22.1, U3.52 (PC11)
UART4_TX: R21.1, R37.1, U3.51 (PC10)
uC_NRST: C60.2, U3.7 (NRST), uC_NRST1.1

Notes on the sheet:
CAN Transceiver
boot0=0 boots from the user flash
Spare serial interface UART3, could be used for serial flashing. Discussion: https://openinverter.org/forum/viewtopic.php?p=76465#p76465
The SWO can be used for tracing. http://stefanfrings.de/stm32/stm32f1.html#traceswo
UART for debugging
100nF on each VDD/VSS pair of the STM
Protection resistors for the case, that the controller and the QCA are powered from different sources which do not synchronously turn on and off
There are more VSS pins (31, 47, 63) which are not shown here. Strange. Nevertheless, in the layout they are correct.
EN=High enables the 65HVD324 transceiver. Low or open would disable it. Other types need open or ground to be active.
Serial Wire Debug SWD
CAN termination resistor. 1k does not hurt if the bus is elsewhere terminated, and helps for setup on desk without additional termination.
XTAL options: Use the two-pin on top, available at JLCPCB. Or use the four-pin on bottom, if available and handsolder is intended. Both 8 MHz.
No external pull-up on the reset. This is the recommended circuit, the STM32F103 has internal pull-up.

Parts:
C27: 22pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C1804
C41, C66, C67: 22uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder; LCSC C12891
C64, C73, C74, C83: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C49678
C65, C82: 10uF 25V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C15850
C68: 47pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C14857
D8: 1N5819WS; D_SOD-323; LCSC C191023
D13: SS54; D_SMB_Handsoldering; LCSC C22452
D18, D19, D21: B5819W; D_SOD-123; LCSC C8598
L13: 10uH; L_6.3x6.3_H3; LCSC C408412
Q2, Q9: AO3401A; SOT-23; LCSC C15127
Q3: 2N7002; SOT-23; LCSC C8545
R23, R56: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C149504
R24: 33k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17633
R38: 22k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17560
R43: 0; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder; LCSC C17888
R64: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17513
R65: 3.3K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C26010
R67: 1M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C22935
TP3V3uC1: TP3V3uC; TestPoint_THTPad_D1.0mm_Drill0.5mm
TP5V1: TP5V; TestPoint_THTPad_D1.0mm_Drill0.5mm
U4: TPS54302; SOT-23-6; LCSC C311983
U5, U10: SMAJ16A-TR; SMA_UNI_STM; LCSC C908770
U6: AMS1117-3.3; SOT-223-3_TabPin2; LCSC C6186

Connections:
3V3_D: R43.2; also elsewhere on the board
3V3_uC: C41.2, C74.2, R43.1, TP3V3uC1.1, U6.2 (VO); also elsewhere on the board
5V: C27.2, C66.2, C67.2, C68.2, C73.2, L13.2, R23.1, TP5V1.1, U6.3 (VI); also elsewhere on the board
12V: D13.2 (A); also elsewhere on the board
12V_P: C65.2, D13.1 (K), Q2.2 (S), Q9.2 (S), R64.2, U4.3 (VIN), U5.1 (K); also elsewhere on the board
BUTTON: Q9.1 (G); also elsewhere on the board
CP: D18.2 (A); also elsewhere on the board
GND: C41.1, C65.1, C66.1, C67.1, C73.1, C74.1, C83.1, Q3.2 (S), R24.1, R38.1, R56.2, R67.2, U4.1 (GND), U5.2 (A), U6.1 (GND), U10.2 (A); also elsewhere on the board
KEEP_POWER_ON: Q3.1 (G); also elsewhere on the board
unnamed: C82.2, C83.2, R65.2, R67.1
unnamed: D8.2 (A), U4.5 (EN)
unnamed: D18.1 (K), R65.1
unnamed: C82.1, D8.1 (K), D19.1 (K), Q2.3 (D), Q9.3 (D), R56.1
unnamed: D21.2 (A), Q2.1 (G), Q3.3 (D), R64.1
unnamed: C64.2, U4.6 (BOOT)
unnamed: C27.1, C68.1, R23.2, R24.2, R38.2, U4.4 (FB)
unnamed: C64.1, L13.1, U4.2 (SW)
PP_WAKE: D21.1 (K); also elsewhere on the board
WAKEUP: D19.2 (A), U10.1 (K); also elsewhere on the board

Notes on the sheet:
goal: 68pF
The combination 100k and 13.3k is recommended by the data sheet for 5V output. We use 22k || 33k, this makes 13.2k.
Option 3 of the power supply (Catphish's stepdown, 3A, 400kHz)
SS54B is rated for 5A. This is at the border, if we drive 6A in the lock/unlock motor.
C82 changes the continous high level of the filtered CP signal to a one-shot pulse when the cable is plugged in. We can therefor choose to shut down the controller even with the cable still plugged in e.g. when no charge power available on solar powered systems

Parts:
C20, C21, C23, C77, C78, C79, C80: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C49678
C71: 1nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C46653
D20: B5819W; D_SOD-123; LCSC C8598
D22, D23: BAV99; SOT-23; LCSC C2500
JP3: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
R28, R32, R34, R36, R41, R55, R57, R61: 47k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17713
R31, R33, R35, R54: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17414
R39, R40: 240; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17572
R42, R53: 22k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17560
R52: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17513
R60: 3.3K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C26010
R62: 18k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C25810
R66: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C149504
R71: 330; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C23138

Connections:
3V3_uC: R31.1, R33.1, R35.1, R54.1, R61.2; also elsewhere on the board
5V: D20.2 (A); also elsewhere on the board
12V_P: D22.2 (A), D23.2 (A), R52.2; also elsewhere on the board
ADC123_IN10: C77.2, R32.2; also elsewhere on the board
ADC123_IN11: C78.2, R34.2; also elsewhere on the board
ADC123_IN12: C79.2, R36.2; also elsewhere on the board
ADC_BUTTON: C20.2, R53.2, R66.2; also elsewhere on the board
ADC_CONN_LOCK_FEEDBACK: C21.2, R55.2; also elsewhere on the board
ADC_HWVARIANT: R61.1, R62.1; also elsewhere on the board
ADC_PP: C23.2, R28.1, R57.2; also elsewhere on the board
ADC_U_HVDC: C80.2, R41.1, R42.2; also elsewhere on the board
BUTTON: D23.3 (K), R52.1, R66.1; also elsewhere on the board
CONN_LOCK_FEEDBACK: R54.2, R55.1; also elsewhere on the board
GND: C20.1, C21.1, C23.1, C71.1, C77.1, C78.1, C79.1, C80.1, D22.1 (K), D23.1 (K), R28.2, R40.1, R42.1, R53.1, R60.2, R62.2; also elsewhere on the board
IN_U_HV: C71.2, R39.2, R41.2; also elsewhere on the board
unnamed: D20.1 (K), R71.1
unnamed: JP3.3 (B), R60.1
unnamed: R39.1, R40.2
PP: D22.3 (K), JP3.2 (C), R57.1, R71.2; also elsewhere on the board
PP_WAKE: JP3.1 (A); also elsewhere on the board
TEMP1: R31.2, R32.1; also elsewhere on the board
TEMP2: R33.2, R34.1; also elsewhere on the board
TEMP3: R35.2, R36.1; also elsewhere on the board

Notes on the sheet:
Divider 2:1 to be able to measure up to 6.6V with the 3.3V ADC ref.
Hardware variant detection: R62 can be increased with each hardware version Table here: https://openinverter.org/wiki/Fully_Open_CCS_Charge_Controller_(FOCCCI) 10k: Foccci 4.2 12k: Foccci 4.3 15k: Foccci 4.4 18k: Foccci 4.5, 4.5b and 5
Current input for HV DC voltage measurement as done in LIM, see https://openinverter.org/forum/viewtopic.php?p=58839#p58839
330 ohms to 5V is the "offical" spec
Analog inputs, e.g. for use with NTCs to ground for temperature measurement or analog feedback contacts or switches.
PlugPresent: - 1k5 to ground for CCS2 - 100 ohm to 1k5 for AC (current limit of the cable) - 150 ohm (button idle) or 480 ohm (button pressed) for CCS1 Some inlets may contain 2k7 or 3k0 to ground. The optional R60 can be used if no external pull down is present. Discussion here: https://openinvert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

Parts:
TP6, TP7, TP9, TP10, TP15, TP16, TP17, TP18, TP20, TP21, TP22, TP25, TP34, TP35, TP47, TP48, TP49, TP50, TP51, TP52, TP53, TP54, TP55, TP56, TP57, TP58, TP59, TP60, TP61, TP62, TP63, TP64: TestPoint; TestPoint_Special_THTPad_D1.9mm_Drill1mm

Board: 4 copper layers, 100.0 x 82.6 mm, 285 parts (3 on the bottom side), 152 nets.

Other parts of the board:
U$2: OI_LOGO

File pcb/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"3V3, 3V3_uC1, CLK1, CS1, GND1, INT1, MISO1, MOSI1, RES1, SWCLK1, SWDIO1, SWGND1, SWO1, UART_GND1, UART_RX1, UART_TX1, uC_NRST1",TestPoint_Special_THTPad_D1.9mm_Drill1mm,17,~,
"C1, C32, C33, C4, C5, C8",0805,6,1.5nF,C1717
"C10, C2, C3, C6, C7",0805,5,220pF,C107145
"C11, C12, C13, C16, C18, C20, C21, C23, C25, C28, C31, C34, C35, C37, C38, C39, C40, C42, C43, C44, C45, C46, C47, C48, C49, C50, C51, C52, C53, C55, C56, C57, C58, C59, C60, C61, C64, C73, C74, C75, C77, C78, C79, C80, C81, C83, C9",0805,47,100nF,C49678
C14,0805,1,1uF,C28323
"C15, C72",0805,2,22nF,C1729
"C17, C29",0603,2,6.8pF,C1679
"C19, C22, C24, C26, C30, C36, C65, C82",0805,8,10uF 25V,C15850
"C27, C62, C63",0805,3,22pF,C1804
"C41, C54, C66, C67, C69, C70",1210,6,22uF,C12891
C68,0805,1,47pF,C14857
"C71, C76",0805,2,1nF,C46653
"D1, D2, D22, D23",SOT-23,4,BAV99,C2500
D10,0805,1,ALIVE,C2296
D11,0805,1,STATEC,C2296
D12,0805,1,CONTACTOR1,C2296
D13,D_SMB_Handsoldering,1,SS54,C22452
"D14, D16, D18, D19, D20, D21, D3, D4, D6, D7",D_SOD-123,10,B5819W,C8598
D15,0805,1,UARTTX,C2296
D5,D_SMA,1,3V9,C438352
D8,D_SOD-323,1,1N5819WS,C191023
D9,0805,1,PWR,C2296
"H1, H2, H4",MountingHole_3.2mm_M3,3,MountingHole,
"IC1, IC2",SOP65P640X120-17N,2,DRV8874QPWPRQ1,C1855818
J1,PinHeader_1x06_P2.54mm_Vertical,1,Conn_01x06,
J20,TE_DTM1312PA12PBR008,1,DTM1312PA12PBR008,
JP1,SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm,1,EN_LOW,
JP2,SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm,1,EN_HIGH,
JP3,SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm,1,SolderJumper_3_Open,
"L1, L8",0805,2,270nH,C281081
"L10, L12, L2, L9",0805,4,Bead 600,C1017
L11,1206,1,4.7uH,C162588
L13,L_6.3x6.3_H3,1,10uH,C408412
"L3, L4, L5, L6, L7",0603,5,1.8uH,C78153
"PB12, PB13, PB5, PB6, TP11, TP12, TP13, TP14, TP26, TP27, TP28, TP29, TP30, TP31, TP38",TestPoint_THTPad_D1.0mm_Drill0.5mm,15,~,
"Q1, Q12, Q13, Q3, Q7, Q8",SOT-23,6,2N7002,C8545
"Q11, Q2, Q9",SOT-23,3,AO3401A,C15127
"Q4, Q5, Q6",SOT-23,3,DTA143Z,C2910150
"R1, R2",0805,2,22,C17561
"R10, R31, R33, R35, R49, R54, R69, R7",0805,8,10k,C17414
"R11, R12, R13, R14, R21, R22, R45, R46, R47",0805,9,220,C17557
"R15, R5",0805,2,33,C17634
"R16, R17, R18, R19, R20, R37, R48, R52, R64",0805,9,1k,C17513
"R23, R56, R58, R66",0805,4,100k,C149504
R24,0805,1,33k,C17633
R25,0805,1,180,C25270
"R26, R30, R51",0805,3,2k7,C17530
R27,0805,1,1k2,C17379
"R28, R32, R34, R36, R41, R55, R57, R61, R63",0805,9,47k,C17713
"R29, R50",0805,2,560,C28636
"R3, R4, R60, R65",0805,4,3.3K,C26010
"R38, R42, R53",0805,3,22k,C17560
"R39, R40",0805,2,240,C17572
R43,1206,1,0,C17888
"R44, R8",0805,2,100,C17408
"R59, R71",0805,2,330,C23138
R6,0805,1,6k2,C4260
R62,0805,1,18k,C25810
R67,0805,1,1M,C22935
R9,0805,1,2.2k,C17520
T1,transformerCL4532A-201,1,~,C2904734
TP1,TestPoint_Pad_D1.0mm,1,1V2,
"TP10, TP15, TP16, TP17, TP18, TP20, TP21, TP22, TP25, TP32, TP33, TP34, TP35, TP47, TP48, TP49, TP50, TP51, TP52, TP53, TP54, TP55, TP56, TP57, TP58, TP59, TP6, TP60, TP61, TP62, TP63, TP64, TP7, TP9",TestPoint_Special_THTPad_D1.9mm_Drill1mm,34,TestPoint,
TP3V3uC1,TestPoint_THTPad_D1.0mm_Drill0.5mm,1,TP3V3uC,
TP5V1,TestPoint_THTPad_D1.0mm_Drill0.5mm,1,TP5V,
U1,SOIC-8_3.9x4.9mm_P1.27mm,1,25Q16,C115407
"U10, U5",SMA_UNI_STM,2,SMAJ16A-TR,C908770
U2,SOIC-8_3.9x4.9mm_P1.27mm,1,SN65HVD230,C12084
U3,LQFP-64_10x10mm_P0.5mm,1,STM32F103RETx,C8322
U4,SOT-23-6,1,TPS54302,C311983
U6,SOT-223-3_TabPin2,1,AMS1117-3.3,C6186
U7,QFN-68-1EP_8x8mm_P0.4mm_EP5.2x5.2mm_ThermalVias,1,QCA 7000,C9900078626
Y1,Crystal_SMD_TXC_7M-4Pin_3.2x2.5mm,1,25MHz,C9006
Y2,Crystal_SMD_TXC_7M-4Pin_3.2x2.5mm,1,8MHz,none
Y3,Crystal_SMD_5032-2Pin_5.0x3.2mm,1,8MHz,C115962

## Commit log

2023-06-20 schematic improvements and board draft
2023-06-20 board: more width for supply, fill, shrink
2023-06-20 v1 ready for production
2023-06-22 docu: clarified GPIO boot config
2023-06-30 docu: how to flash the SPIFLASH
2023-07-06 doc: power supply options
2023-07-06 docu: todo list extended
2023-07-06 started adding power supply
2023-07-07 Added option 3 for the power supply
2023-07-08 Fix: Bias resistor corrected. Docu: first run.
2023-07-10 added power supply and STM32, removed first option stepdown, added CP logic, corrected stepdown converter
2023-07-10 docu: improved readme
2023-07-10 added sheets for inputs and outputs. layout draft.
2023-07-11 layout for stm, supply, drivers, flash programming connector
2023-07-11 fix: can transceiver enable high. fix: uart LED low active. fix: contactor LED low active. fix: LED names in silkscreen.
2023-07-12 fix: divider on the stepdown. fix: non-inverted contactor drivers. fix: part number of 8MHz. add: mounting holes and spare grid. add: LIM HVDC input. docu: todo list
2023-07-12 docu: added schematic as pdf
2023-07-13 docu: interface draft. prod: gerber 2023-07-12
2023-07-28 docu: charging loop reached with the 2023-07-12 board
2023-08-02 docu: added todo item
2023-08-10 added TE DEUTSCH connector and housing
2023-08-10 added RGB LED highside drivers
2023-08-11 first draft with the DRV8874 hbridge driver. Added 3D models.
2023-08-11 added cutted corners
2023-08-15 wired the drv8874. Added spare holes. Flash connector larger holes
2023-08-16 changed to 4 layers. Added button, PP and lock feedback. New testpoints to avoid courtyard warnings.
2023-08-16 routed driver outputs for contactors and lock motor to PWM TIM3 ports. Use protected 12V for DRV.
2023-08-16 all 100nF now 0805. Todo list cleaned up.
2023-08-16 added CP sensing. Added 5V on the connector. Created gerber and pdf
2023-08-22 added some jlcpcb part numbers, adjusted some footprints and values accordingly.
2023-08-22 added more part numbers
2023-08-24 more partnumbers assigned. split difficult values into two parts. add protection of CP_SENSE port
2023-08-24 footprint corrections. some layout adaptions for new footprints (ongoing)
2023-08-24 docu: status update in readme
2023-08-25 layout: all components to front (WIP)
2023-08-26 layouted all the 0805 and botton-to-top changes. Pin description on bottom silk screen.
2023-08-26 added alternative 1206 for the 0603 capacitors
2023-08-26 installed FabricationToolkit, used it to create gerber, drill, BOM and placement for JLCPCB
2023-08-26 added readme with JLCPCB offers
2023-08-26 pcb: added 3D model of the connector
2023-08-28 BOM consolidation: XTAL options and back to 8MHz. Replace internal connectors by testpoints. Use T with integrated R for CP switching. Fix: Footprint Q7-Q9 corrected.
2023-08-28 added part number for the big 10uH
2023-09-07 docu: low power mode requirements. Docu: JLCPCB footprint orientation.
2023-09-07 added rotation attribute to get the correct footprint rotation at JLCPCB
2023-09-10 docu: V4 2023-09-10 finished. Added board history.
2023-09-10 docu: fixed wrong picture file names in readme
2023-09-10 docu: update of todo. pictures of QCA pins added
2023-09-12 docu: solderfail fotos
2023-09-24 docu: added picture solderlesson
2023-09-27 docu: added issues of the V3 board
2023-09-30 docu: added cost estimation for the V3/V4
2023-09-30 docu: added solder lessons
2023-09-30 docu: typos and formatting
2023-10-08 docu: V3 demo charging results
2023-10-25 layout fix: bigger gap between QCA corner and via, to avoid solder bridge to corner frame metal. Silkscreen improvements.
2023-10-25 docu: news regarding ordering the v4.1
2023-10-25 docu fix
2023-10-26 Update: Docu
    Added Info about the current order status of V4 in the corresponding section
2023-12-14 docu: todo list
2023-12-14 docu: news
2023-12-18 fix rx shortcut. add transformer. correct part number of NCV. Correct footprints of U1 and L11. add mounting holes. stepdown layout improved. added TVS at 12V
2023-12-18 fix: origin of the transformer into the middle. Fix: rotation attributes for jlcpcb
2023-12-18 stepdown L and layout further optimized. fix rotation and layout
2023-12-18 fix: for the big elcap, use jlc part C3445244 to avoid running into expensive standard service
2023-12-18 added openinverter logo
2024-01-10 docu: added some ideas for todos (thanks maciek16c)
2024-01-28 docu: added the PP todo item
2024-01-28 docu: added foccci logos and introduction
2024-02-05 docu: added todo for version indication analog circuit
2024-02-06 WIP: PP pull-up and divider. variant detection. ipropi connected to ADC.
2024-02-06 v4.2 layout finished. release files and readme
2024-02-19 Added pinout graphic
2024-02-19 feature: Added wakeup logic
2024-02-19 Corrected pin map for CJ431 Increased variant resistor Added pull-down for Wakeup
2024-02-19 Routed new parts
2024-02-19 Corrected DRC errors
2024-02-23 docu: foto and issue description of the v4.2
2024-02-27 docu: added issues of the V4.2
2024-02-27 Moved most vias away from pads
2024-02-27 Made relay drivers PMOS with gate drivers and free wheeling diode
2024-02-28 docu: patches for v4.2
2024-02-28 Using another motor driver IC for contactor control
2024-03-08 Redesigned wakeup circuit
2024-03-18 Added 1M discharge resistor for CP enable Removed momentary turn-on resitor for PP enable because always charged by uC voltage divider
2024-03-18 BOM optimization
2024-04-04 Made PP standby and button pullup 1k Improved connection of TVS diode
2024-04-04 moved production files
2024-04-05 Moved JP3 further away from header Added production files Updated pin description photo
2024-04-07 docu: added trouble shooting / FAQ chapter
2024-05-05 docu: added trouble shooting infos for CP and PP
2024-05-24 Re-assigned pins to be able to make one loom to the charge port and one to the car
2024-05-24 Forgot to save
2024-05-24 More re-assignment
2024-05-24 Updated graphic
2024-05-25 Fix possible collision with enclosure
2024-06-27 Corrected silkscreen, moved parts away from enclosure rail
2024-06-27 version 5
2024-07-08 added issue+todo for v5
2024-07-09 added diode D8, corrected resistors, corrected rotations. V5.1
2024-07-10 docu: added test list
2024-07-10 docu: added todo
2024-07-15 docu: extended testlist
2024-10-26 docu: testlist improved
2024-10-31 5.2pre: transformerless RF path. TVS. Demo placement for alternative connectors.
2024-11-27 added alternative 6-pin headers. Added uart3 test points. V5.2pre2
2024-11-28 layout improvements for #7 sub 2 and sub 4 and partly sub 7
2024-12-04 layout improvements for #7 sub 7 and 12
2024-12-10 some layout fixes for #7
2024-12-11 corrected some rotations for JLC. Version 5.2p7
2025-01-30 Added TC2030 for programming STM32
2025-01-30 Forgot to save before committing...
2025-05-26 added pdfs for schematics of v5 and v5.2p7
2025-05-27 Changed RF dampening resistors from 100 to 22 Ohms
2025-05-27 directory cleanup
2025-06-04 v5.2p10 intermediate: added JTAG. Layout optimizations. Corrected link of the new 22 ohms.
2026-05-29 added freecad file for test adapter
2026-05-29 mech: foccci tester: increased spare-out for nuts on snapper holder to 9.5mm
